# Lets the recipe find SUPERBIRD_WESTON_SPLASH_IMAGE (set in the distro conf) in files/ here.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
