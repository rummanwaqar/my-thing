# Same tz version as tzdata, so zic matches the data: see my-thing-tz-version.inc.
require my-thing-tz-version.inc
